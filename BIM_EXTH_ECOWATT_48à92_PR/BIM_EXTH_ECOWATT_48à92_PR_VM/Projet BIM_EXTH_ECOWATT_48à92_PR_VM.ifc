Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2021-04-14T17:52:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 14 17:52:51 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{BB7523B7-D86C-4B53-B6D3-42C44712B9A2}\ifc * Database version: 5507 * Database creation date: Wed Apr 14 17:52:50 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 14 17:52:50 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 14 17:52:50 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PR 48 VM, BIM_EXTH_ECOWATT_48_PR_VM:EXTH ECOWATT PR 48 VM:293624
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: yes; 4_poignees: no; Grille_extraction: 0.41 m; Nom de la famille: BIM_EXTH_ECOWATT_48_PR_VM; Visibilité_marque: yes
Type - Cotes(Type) - A: 1.119 m; B: 0.985 m; B': 1.065 m; C: 0.8 m; E: 0.7 m; F: 0.918 m; G: 0.433 m; H: 0.33 m; Hauteur_porte: 0.63 m; Hauteur_traverse: 0.101 m; I: 0.32 m; J: 0.34 m; Largeur_porte: 0.55 m; Largeur_traverse: 0.156 m; ØD1: 0.56 m; ØD1_Int: 0.556 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410102; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 48 VM Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 48 VM; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 107 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 720 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 5400 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM; Famille et type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM; ID du type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM; Type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 5.01209 m2; Volume: 0.654831 m3
Données d'identification - Identifiant: 44
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 48 VM ISOLE, BIM_EXTH_ECOWATT_48_PR_VM:EXTH ECOWATT PR 48 VM ISOLE:293638
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: yes; 4_poignees: no; Visibilité_marque: yes; Grille_extraction: 0.41 m; Nom de la famille: BIM_EXTH_ECOWATT_48_PR_VM
Type - Cotes(Type) - A: 1.119 m; B: 0.985 m; B': 1.065 m; C: 0.827 m; E: 0.7 m; F: 0.918 m; G: 0.433 m; H: 0.33 m; Hauteur_porte: 0.63 m; Hauteur_traverse: 0.101 m; I: 0.32 m; J: 0.34 m; Largeur_porte: 0.55 m; Largeur_traverse: 0.156 m; ØD1: 0.56 m; ØD1_Int: 0.556 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410100; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 48 VM IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 48 VM ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 120 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 720 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 5400 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE; Famille et type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE; ID du type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE; Type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 5.06655 m2; Volume: 0.681857 m3
Données d'identification - Identifiant: 45
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 48 VM ISOLE Tri, BIM_EXTH_ECOWATT_48_PR_VM:EXTH ECOWATT PR 48 VM ISOLE Tri:293652
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: yes; 4_poignees: no; Visibilité_marque: yes; Grille_extraction: 0.41 m; Nom de la famille: BIM_EXTH_ECOWATT_48_PR_VM
Type - Cotes(Type) - A: 1.119 m; B: 0.985 m; B': 1.065 m; C: 0.827 m; E: 0.7 m; F: 0.918 m; G: 0.433 m; H: 0.33 m; Hauteur_porte: 0.63 m; Hauteur_traverse: 0.101 m; I: 0.32 m; J: 0.34 m; Largeur_porte: 0.55 m; Largeur_traverse: 0.156 m; ØD1: 0.56 m; ØD1_Int: 0.556 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410101; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 48 VM IS Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 48 VM ISOLE Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 120 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.5 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 720 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 5400 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE Tri; Famille et type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE Tri; ID du type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE Tri; Type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM ISOLE Tri
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 5.06655 m2; Volume: 0.681857 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 48 VM Tri, BIM_EXTH_ECOWATT_48_PR_VM:EXTH ECOWATT PR 48 VM Tri:293666
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: yes; 4_poignees: no; Visibilité_marque: yes; Grille_extraction: 0.41 m; Nom de la famille: BIM_EXTH_ECOWATT_48_PR_VM
Type - Cotes(Type) - A: 1.119 m; B: 0.985 m; B': 1.065 m; C: 0.8 m; E: 0.7 m; F: 0.918 m; G: 0.433 m; H: 0.33 m; Hauteur_porte: 0.63 m; Hauteur_traverse: 0.101 m; I: 0.32 m; J: 0.34 m; Largeur_porte: 0.55 m; Largeur_traverse: 0.156 m; ØD1: 0.56 m; ØD1_Int: 0.556 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410103; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 48 VM Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 48 VM Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 107 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.5 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 720 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 5400 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM Tri; Famille et type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM Tri; ID du type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM Tri; Type: BIM_EXTH_ECOWATT_48_PR_VM: EXTH ECOWATT PR 48 VM Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 5.01209 m2; Volume: 0.654831 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
